## firmware/esp-pot-o-miner/sdkconfig.defaults
```kconfig
# Enable ESP32 hardware SHA for mbedtls (faster sha256_raw / SHA256Ctx)
CONFIG_MBEDTLS_HARDWARE_SHA=y
```
